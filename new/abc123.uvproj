# Keil uVision project abc123.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: NUC140VE3AN Nuvoton
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x1FFFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: abc123
  c include: ..\..\NuvotonPlatform_Keil\Include\System;..\..\NuvotonPlatform_Keil\Src\Driver;..\..\NuvotonPlatform_Keil\Src\NUC1xx-LB_002;..\..\NuvotonPlatform_Keil\Include\NUC1xx-LB_002;..\..\NuvotonPlatform_Keil\Include\Driver;..\..\CMSIS\CM0\CoreSupport;..\..\NuvotonPlatform_Keil\Include\Driver
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Source Group 1
    ./: startup_NUC1xx.s
    ../../CMSIS/CM0/CoreSupport/: core_cm0.c
    ../../CMSIS/CM0/DeviceSupport/Nuvoton/NUC1xx/: system_NUC1xx.c
    ../../NuvotonPlatform_Keil/Src/NUC1xx-LB_002/: Ascii_Table.C LCD_Driver.c
    C:/Keil/ARM/Startup/: RTX_Conf_CM.c
    ../../NuvotonPlatform_Keil/Src/Driver/: DrvGPIO.c DrvSYS.c
  group abc
    ./: abc123.c
